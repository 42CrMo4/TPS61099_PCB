# Repository 42CrMo4/TPS61099_PCB

File README.md:

# Description. 

Breakout Board for the TPS61099x line from Ti.

## KiCad design design.kicad_pcb

Board: 2 copper layers, 25.0 x 22.9 mm, 14 parts (0 on the bottom side), 6 nets.

Parts:
C1, C2, C3, C4: C_Small; C_0805_2012Metric
J1, J2: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J3, J4: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
JP1, JP2: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1: L_Small; L_1008_2520Metric
R1, R2: R_Small; R_0805_2012Metric
U1: TPS61099YFFT; BGA6N40P3X2_122X88X62N

Connections:
En: J3.3, J4.3, JP1.1 (A), U1.C1 (EN)
FB: JP2.1 (A), R1.2, R2.1, U1.C2 (FB)
GND: C1.2, C2.2, C3.2, C4.2, J1.2, J2.2, J3.1, J4.1, JP2.2 (B), R2.2, U1.A2 (GND)
SW: L1.2, U1.B1 (SW)
Vin: C1.1, C2.1, J1.1, J2.1, JP1.2 (B), L1.1, U1.A1 (VIN)
Vout: C3.1, C4.1, J3.2, J4.2, R1.1, U1.B2 (VOUT)

File Fabrication/BoM/design-bom-short.csv:

Row,Description,Part,References,Value,Footprint,Quantity Per PCB,Status,Datasheet,STANDARD,PARTREV,MAXIMUM_PACKAGE_HEIGHT,MANUFACTURER
1,"Unpolarized capacitor, small symbol",C_Small,C1 C2 C3 C4,C_Small,C_0805_2012Metric,4, ,~,,,,
2,"Generic connector, single row, 01x02, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x02,J2,Conn_01x02,PinHeader_1x02_P2.54mm_Vertical,1, ,~,,,,
3,"Generic connector, single row, 01x03, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x03,J4,Conn_01x03,PinHeader_1x03_P2.54mm_Vertical,1, ,~,,,,
4,"Inductor, small symbol",L_Small,L1,L_Small,L_1008_2520Metric,1, ,~,,,,
5,"Resistor, small symbol",R_Small,R1 R2,R_Small,R_0805_2012Metric,2, ,~,,,,
6,,TPS61099YFFT,U1,TPS61099YFFT,BGA6N40P3X2_122X88X62N,1, ,,IPC 7351B,K,0.625mm,Texas Instruments

## Commit log

2022-03-20 remove template stuff
2022-03-20 add TPS61099
2022-03-20 remove kicad 5 stuff
2022-03-20 PCB Add variables
2022-03-20 Kicad v6 workflow adaption
2022-03-20 WF kicad v6 adaption
2022-03-20 Update Bom and PCB_top
2022-03-20 WF kicad v6 adaption - file names
2022-03-20 remove date variable
2022-03-20 remove 3D model TPS61099
2022-03-20 remove step output
2022-03-20 PCB Add edge cut
2022-03-20 PCB add 3D model TPS61099
2022-03-20 WF Add step output
2022-03-21 PCB Add Date SilkScreen
2022-03-21 PCB Add date in sheet
2022-03-21 WF remove Gerber from generate output wf
2022-03-21 Add bottom pcb PNG to readme
2022-03-21 PCB Add generic 3D path
2022-03-22 Add autosafe to gitignore
2022-03-22 SCH/PCB Add initial design
2022-03-23 SCH/PCB desin according Datasheet
2022-03-24 WF Add RC Release Workflow
2022-03-24 Add Release Note update
2022-03-24 WF Add RC name to RC release WF
2022-03-24 WF RC no gerber drills
2022-03-27 PCB Move Silkscreen
2022-03-27 WF Added Gerber Drills back in again
    Closed with update from Kibot?
2022-03-27 WF Add ID prefix
2022-03-27 PCB Add Silkscreen information
2022-03-27 Add Bottom PNG
2022-03-28 WF added link variables to artifact pictures
2022-03-28 WF correct variable names?
2022-03-28 WF variable switch corrected
2022-03-28 WF format
2022-03-28 WF add variable input form rc to release
2022-03-28 DOC Add TPS61099 design Documentation
    From the wbdesign web tool
2022-03-28 WF change to only Major.Minor semantic versioning Tag
2022-04-01 WF use kibot global naming
2022-04-01 WF update global naming
2022-04-01 Update update_bom_pcbtop.yml
    run not on kibot changes
2022-04-03 WF: git lfs needed?
2022-04-03 WF remove git lfs
2022-04-03 WF remove com generation on WF update
2022-04-03 WF only one upload artifacts
2022-04-03 DEL Bom artifacts
2022-04-03 WF Bom upload do not use global naming
2022-04-03 WF typo (quote)
2022-04-03 WF naming convention?
2022-04-03 WF kibot bom option problem?
2022-04-03 WF rename workflow
2022-04-13 Add/Move documentation TI
    WBDesign documentation
2022-04-17 Add property test bash script
2022-04-17 WF/Docs Moved release notes/checklist
    Moved release notes/checklist to docs folder
2022-04-17 WF use temp folder for output generation
    Use the Fabrication_temp folder instead of Fabrication, which interfere with the bom/pcbtop upload
2022-04-17 Add .kicad_prl
    kicad_prl - local kicad user setting (show/hide layer etc.)
